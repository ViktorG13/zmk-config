## boards/shields/nicenano/Kconfig.defconfig
```kconfig
if SHIELD_NICENANO

config ZMK_KEYBOARD_NAME
    default "nicenano"

endif # SHIELD_NICENANO
```
